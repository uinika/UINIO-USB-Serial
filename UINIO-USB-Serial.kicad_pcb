# Repository uinika/UINIO-USB-Serial

File README.md:

# UINIO-USB-Serial 串行协议转换器

[**UINIO-USB-Serial**](https://gitee.com/uinika/UINIO-USB-Serial) 是一款基于**沁恒**高速 USB 2.0 转接芯片 [**CH347T**](https://www.wch.cn/products/CH347.html) 的 USB 串行协议转换工具，支持 USB 接口转 `GPIO`、`UART`、`I²C`、`SPI`、`JTAG`, 可以用于调试 3.3V 电平的微控制器与外设的通信，也可以配合使用 [UINIO-Signal-Translator](https://github.com/uinika/UINIO-Signal-Translator) 完成 `3.3V` 到 `1.8V` 的高速信号转换，从而实现对 FPGA 芯片的调试与下载。

## 设计概要

1. 主控芯片 **CH347T** 采用了易于购买的 `TSSOP20` 封装；
2. 工作模式采用 `P1` 与 `P2` 排针的**跳线帽**进行配置；
3. 添加有 5 个 `1mm` 直径固定螺丝孔，方便与外壳进行固定组装；
4. 分类引出了 UART1 和 UART2、SPI、I²C、JTAG 五条通信总线的排针，配置好工作模式之后就可以快速接线使用；
5. 配合 [UINIO-Signal-Translator](https://gitee.com/uinika/UINIO-Signal-Translator) 可以将电平信号转换为 FPGA 芯片常用的 `1.8V`；

## 工作模式简介

**UINIO-USB-Serial** 可以支持下面的四种工作模式：

1. **USB ➞ UART**：支持两路 UART 串行接口，每一路的波特率最高可以达到 `9Mbps`。
2. **USB ➞ I²C**：处于 I²C 主设备模式，支持 4 种传输速度。
3. **USB ➞ SPI**：处于 SPI 主设备模式，最高频率可以达到 `36MHz`，并且支持 2 路片选信号线，可以分时操作两个 SPI 从设备。
4. **USB ➞ JTAG**：支持标准四线 JTAG 协议，最高频率可以达到 `18Mbit/s`。

## 工作模式配置

这些模式分别由 **CH347T** 的 `DTR1` 和 `RTS1` 引脚的电平状态进行控制：

| 排针 P1  | 排针 P2  | 工作模式                |
| -------- | -------- | ----------------------- |
| `低电平` | `低电平` | UART1 + JTAG            |
| `高电平` | `高电平` | UART1 + UART0           |
| `高电平` | `低电平` | UART1 + SPI + I2C (HID) |
| `低电平` | `高电平` | UART1 + SPI + I2C (VCP) |

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-USB-Serial 开源项目提供了如下一系列技术参考资料：

- [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-USB-Serial.html)

## KiCad design UINIO-USB-Serial.kicad_pcb

Parts:
C1, C3: 0.1uF; C_0402_1005Metric
C2, C4: 20pF; C_0402_1005Metric
C5, C6: 1uF; C_0603_1608Metric
D1: LED Blue; LED_0603_1608Metric
D2: LED_Red; LED_0603_1608Metric
J1, J4, J7: Conn_01x07_Pin; PinHeader_1x07_P2.54mm_Vertical
J2: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J5: 排针P1; PinHeader_1x03_P2.54mm_Vertical
J6: 排针P2; PinHeader_1x03_P2.54mm_Vertical
R1, R6, R7, R8, R9: 4.7K; R_0402_1005Metric
R2, R3: 5.1K; R_0603_1608Metric
R4, R5: 2K; R_0402_1005Metric
U1: CH347T; TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL
U2: ME6211C33M5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/CTS0/SCK/TCK: J1.3, J2.5, J7.3, U1.6 (CTS0/GPIO0/SCK/TCK)
/CTS1/IO6: J4.3, U1.2 (CTS1/GPIO6)
/DCD0/IO4: D1.1 (K), J2.7, U1.15 (DCD0/GPIO4/ACT)
/DSR0/CS0/TMS: J1.2, J2.6, J7.2, U1.5 (DSR0/GPIO2/SCS0/TMS)
/DTR0/IO5: J1.6, J2.2, J7.6, U1.9 (TNOW0/DTR0/GPIO5/SCS1/TRST)
/DTR1: J4.6, J6.2, U1.10 (TNOW1/DTR1)
/I2C_SCL: J2.9, J3.2, U1.11 (RI0/GPIO3/SCL)
/I2C_SDA: J2.8, J3.3, U1.12 (RXD0/SDA)
/JTAG_TDI: J1.5, J2.3, J7.5, U1.8 (TXD0/MOSI/TDI)
/JTAG_TDO: J1.4, J2.4, J7.4, U1.7 (RTS0/GPIO1/MISO/TDO)
/RTS1/IO7: J4.2, J5.2, U1.13 (RTS1/GPIO7)
/RXD1: J4.5, U1.4 (RXD1)
/TXD1: J4.4, U1.3 (TXD1)
/USB_Data+: U1.17 (UD+), USB1.A6 (DP1), USB1.B6 (DP2)
/USB_Data-: U1.16 (UD-), USB1.A7 (DN1), USB1.B7 (DN2)
/VDD_3.3V: C3.1, C6.2, J1.7, J2.10, J3.1, J4.7, J7.1, R1.1, R4.2, R5.2, R8.2, R9.2, U1.14 (VCC), U2.5 (Vout)
/VDD_5V: C5.2, U2.1 (Vin), U2.3 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
GND: C1.2, C2.1, C3.2, C4.1, C5.1, C6.1, D2.1 (K), J1.1, J2.1, J3.4, J4.1, J7.7, R2.2, R3.2, R6.2, R7.2, U1.18 (GND), U2.2 (Vss), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND), Y1.2, Y1.4
unnamed: D1.2 (A), R4.1
unnamed: D2.2 (A), R5.1
unnamed: J5.1, R6.1
unnamed: J5.3, R8.1
unnamed: J6.1, R7.1
unnamed: J6.3, R9.1
unnamed: C1.1, R1.2, U1.1 (RST#)
unnamed: C4.2, U1.19 (XI), Y1.3
unnamed: C2.2, U1.20 (XO), Y1.1
unnamed: R2.1, USB1.A5 (CC1)
unnamed: R3.1, USB1.B5 (CC2)

Notes on the sheet:
JTAG 接口
SPI 接口
UART1 接口
3.3V 线性稳压电路
USB Type-C 接口电路
I2C 接口
模式切换开关
UART0 接口
CH347T USB2.0 高速转接芯片
排针P1 排针P2 DTR1 RTS1 MODE 高电平 高电平 1 1 0 低电平 高电平 0 1 1 高电平 低电平 1 0 2 低电平 低电平 0 0 3

Board: 2 copper layers, 55.3 x 28.1 mm, 33 parts (0 on the bottom side), 29 nets.

Other parts of the board:
HOLE**: Hole-1mm
HOLE**#2, HOLE**#3, HOLE**#4, HOLE**#5: Hole-1mm

## Commit log

2023-12-25 Init UINIO-USB-Serial project.
2023-12-26 Create KiCad project and attach some libraries.
2023-12-26 Update README.md.
2023-12-26 Finish CH347 core board schema.
2023-12-27 Update UINIO-USB-Serial schematic diagram.
2023-12-28 Complete the schematic test.
2023-12-30 Finish PCB layout.
2024-01-07 Complete PCB wiring.
2024-01-08 Release UINIO-USB-Serial version 1.0.0.
